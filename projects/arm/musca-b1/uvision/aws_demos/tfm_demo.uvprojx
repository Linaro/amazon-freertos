# Keil uVision project tfm_demo.uvprojx, settings and files
target Library Model (6090000::V6.9::.\ARMCLANG)
  device: Musca_B1:Cortex-M33-0 ARM
  pack: ARM.Musca_B1_BSP.1.1.0
  cpu: IRAM(0x30000000,0x00080000) IRAM2(0x20000000,0x00080000) IROM(0x1A000000,0x00200000) IROM2(0x0A000000,0x00200000) XROM(0x10000000,0x00800000) XROM2(0x00000000,0x00800000) XROM3(0x1A200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: tfm_demo
  AfterMake: fromelf.exe --bin --output=.\Objects\MUSCA_B_DEMO.bin .\Objects\tfm_demo.axf
  AfterMake: python ../../../../../vendors/arm/boards/musca-b1/aws_demos/tfm_rtos_mcuboot_integrate.py --ns_bin=.\Objects\MUSCA_B_DEMO.bin --tfm=..\..\..\..\..\..\trusted-firmware-m --platform=MUSCA_B1
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: MUSCA_B_DEMO BL2
  c include: ..\..\..\..\..\freertos_kernel\include;..\..\..\..\..\..\trusted-firmware-m\build\install\export\tfm\include;..\..\..\..\..\vendors\arm\boards\musca-b1\aws_demos\application_code\arm_code;..\..\..\..\..\vendors\arm\driver_library\cmsis\include;..\..\..\..\..\vendors\arm\driver_library\cmsis\config;..\..\..\..\..\vendors\arm\driver_library\Device\config;..\..\..\..\..\vendors\arm\driver_library\Device\include;..\..\..\..\..\vendors\arm\driver_library\drivers;..\..\..\..\..\vendors\arm\driver_library\gen_support;..\..\..\..\..\vendors\arm\boards\musca-b1\aws_demos\config_files;..\..\..\..\..\freertos_kernel\portable\GCC\ARM_CM33_TFM;..\..\..\..\..\vendors\arm\driver_library\cmsis\drivers
  memory RVCT1: ROM 0x10000000 size 0x800000
  memory RVCT2: ROM 0x0 size 0x800000
  memory RVCT3: ROM 0x1a200000 size 0x200000
  memory RVCT4: ROM 0x1a000000 size 0x200000
  memory RVCT5: ROM 0xa000000 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x80000
  memory RVCT10: RAM 0x20000000 size 0x80000
  scatter file: ..\..\..\..\..\vendors\arm\boards\musca-b1\aws_demos\musca_ns.sct
  group vendors/arm/boards/musca-b1/aws_demos/application_code
    ../../../../../vendors/arm/boards/musca-b1/aws_demos/application_code/: main.c
  group freertos_kernel/port
    ../../../../../freertos_kernel/portable/Common/: mpu_wrappers.c
    ../../../../../freertos_kernel/portable/MemMang/: heap_4.c
    ../../../../../../trusted-firmware-m/build/install/export/tfm/src/: tfm_ns_interface.c
    ../../../../../freertos_kernel/portable/GCC/ARM_CM33_TFM/: os_wrapper_freertos.c port.c portasm.c portasm.h portmacro.h tz_context.h tz_context_mgmt.c tz_context_mgmt.h
  group tfm_services
    ../../../../../../trusted-firmware-m/build/install/export/tfm/src/: tfm_sst_func_api.c tfm_sst_ipc_api.c tfm_psa_ns_api.c
    ../../../../../../trusted-firmware-m/build/install/export/tfm/include/: tfm_sst_defs.h tfm_veneers.h
    ../../../../../../trusted-firmware-m/build/install/export/tfm/veneers/: s_veneers.o
  group freertos_kernel
    ../../../../../freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group vendors/arm/boards/musca-b1/aws_demos/config_files
    ../../../../../vendors/arm/boards/musca-b1/aws_demos/config_files/: FreeRTOSConfig.h
  group vendors/arm/driverlibrary
    ../../../../../vendors/arm/driver_library/cmsis/config/: cmsis_driver_config.h RTE_Device.h
    ../../../../../vendors/arm/driver_library/cmsis/drivers/: Driver_Common.h Driver_USART.c Driver_USART.h
    ../../../../../vendors/arm/driver_library/cmsis/include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm33.h
    ../../../../../vendors/arm/driver_library/Device/config/: device_cfg.h
    ../../../../../vendors/arm/driver_library/Device/include/: cmsis.h platform_retarget_dev.h platform_retarget_pins.h system_cmsdk_musca.h system_core_musca.h system_musca.h uart_musca_b.h
    ../../../../../vendors/arm/driver_library/Device/source/: platform_retarget_dev.c
    ../../../../../vendors/arm/driver_library/Device/startup/: startup_cmsdk_musca_ns.s system_core_init.c
    ../../../../../vendors/arm/driver_library/drivers/: uart_pl011_drv.c uart_pl011_drv.h uart_stdout.c uart_stdout.h
    ../../../../../vendors/arm/driver_library/gen_support/: hardware_setup.c hardware_setup.h print_log.c print_log.h
target IPC Model (6090000::V6.9::.\ARMCLANG)
  device: Musca_B1:Cortex-M33-0 ARM
  pack: ARM.Musca_B1_BSP.1.1.0
  cpu: as above
  output: tfm_demo
  AfterMake: as above
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: as above
  memory RVCT1: ROM 0x10000000 size 0x800000
  memory RVCT2: ROM 0x0 size 0x800000
  memory RVCT3: ROM 0x1a200000 size 0x200000
  memory RVCT4: ROM 0x1a000000 size 0x200000
  memory RVCT5: ROM 0xa000000 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x80000
  memory RVCT10: RAM 0x20000000 size 0x80000
  scatter file: as above
