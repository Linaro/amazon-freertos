# Keil uVision project tfm_pkcs11_test.uvprojx, settings and files
target IPC Model (6090000::V6.9::.\ARMCLANG)
  device: Musca_B1:Cortex-M33-0 ARM
  pack: ARM.Musca_B1_BSP.1.1.0
  cpu: IRAM(0x30000000,0x00080000) IRAM2(0x20000000,0x00080000) IROM(0x1A000000,0x00200000) IROM2(0x0A000000,0x00200000) XROM(0x10000000,0x00800000) XROM2(0x00000000,0x00800000) XROM3(0x1A200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: tfm_pkcs11_test +hex
  AfterMake: fromelf.exe --bin --output=.\Objects\MUSCA_B_TEST.bin .\Objects\tfm_pkcs11_test.axf
  AfterMake: python ../../../../../vendors/arm/boards/musca-b1/aws_tests/tfm_rtos_mcuboot_integrate.py --ns_bin=.\Objects\MUSCA_B_TEST.bin --tfm=..\..\..\..\..\..\trusted-firmware-m --platform=MUSCA_B1
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: UNITY_INCLUDE_CONFIG_H
  c include: ..\..\..\..\..\..\trusted-firmware-m\build\install\export\tfm\include;..\..\..\..\..\freertos_kernel\include;..\..\..\..\..\freertos_kernel\portable\GCC\ARM_CM33_TFM;..\..\..\..\..\vendors\arm\driver_library\drivers;..\..\..\..\..\vendors\arm\driver_library\Device\include;..\..\..\..\..\vendors\arm\driver_library\Device\config;..\..\..\..\..\vendors\arm\driver_library\cmsis\config;..\..\..\..\..\vendors\arm\driver_library\gen_support;..\..\..\..\..\vendors\arm\driver_library\cmsis\include;..\..\..\..\..\vendors\arm\boards\musca-b1\aws_tests\application_code\arm_code;..\..\..\..\..\vendors\arm\boards\musca-b1\aws_tests\config_files;..\..\..\..\..\freertos_kernel\include;..\..\..\..\..\libraries\abstractions\pkcs11\include;..\..\..\..\..\libraries\freertos_plus\standard\pkcs11\include;..\..\..\..\..\libraries\3rdparty\pkcs11;..\..\..\..\..\tests\include;..\..\..\..\..\libraries\3rdparty\unity\src;..\..\..\..\..\libraries\3rdparty\unity\extras\fixture\src;..\..\..\..\..\demos\dev_mode_key_provisioning\include;..\..\..\..\..\libraries\freertos_plus\standard\crypto\include;..\..\..\..\..\libraries\3rdparty\mbedtls\include;..\..\..\..\..\libraries\c_sdk\standard\common\include;..\..\..\..\..\libraries\freertos_plus\standard\utils\include;..\..\..\..\..\libraries\c_sdk\standard\common\include\private;..\..\..\..\..\libraries\abstractions\pkcs11\mbedtls;..\..\..\..\..\vendors\arm\driver_library\cmsis\drivers;..\..\..\..\..\vendors\arm\boards\musca-b1\aws_tests\application_code\arm_code;..\..\..\..\..\libraries\freertos_plus\standard\utils\include;..\..\..\..\..\libraries\c_sdk\standard\common\include;..\..\..\..\..\libraries\abstractions\wifi\include;..\..\..\..\..\..\trusted-firmware-m\platform\ext\target\musca_b1;..\..\..\..\..\vendors\arm\third_party\ESP_AT_Lib-0.5.0\src\include;..\..\..\..\..\libraries\abstractions\secure_sockets\include;..\..\..\..\..\..\trusted-firmware-m\build\install\export\tfm\include\psa;..\..\..\..\..\libraries\freertos_plus\standard\tls\include
  memory RVCT1: ROM 0x10000000 size 0x800000
  memory RVCT2: ROM 0x0 size 0x800000
  memory RVCT3: ROM 0x1a200000 size 0x200000
  memory RVCT4: ROM 0x1a000000 size 0x200000
  memory RVCT5: ROM 0xa000000 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x80000
  memory RVCT10: RAM 0x20000000 size 0x80000
  scatter file: ..\..\..\..\..\vendors\arm\boards\musca-b1\aws_tests\musca_ns.sct
  group libraries/abstractions/pkcs11/test
    ../../../../../libraries/abstractions/pkcs11/test/: iot_test_pkcs11.c
    ../../../../../vendors/arm/boards/musca-b1/aws_tests/application_code/arm_code/: iot_test_pkcs11_psa.c
  group tests/common
    ../../../../../tests/common/: iot_test_freertos.c aws_test.c aws_test_framework.c aws_test_runner.c
  group freertos_kernel/include
    ../../../../../freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group vendors/arm/driverlibrary
    ../../../../../vendors/arm/driver_library/cmsis/config/: cmsis_driver_config.h RTE_Device.h
    ../../../../../vendors/arm/driver_library/cmsis/drivers/: Driver_Common.h Driver_USART.h Driver_USART.c
    ../../../../../vendors/arm/driver_library/cmsis/include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm33.h
    ../../../../../vendors/arm/driver_library/Device/config/: device_cfg.h
    ../../../../../vendors/arm/driver_library/Device/include/: cmsis.h platform_retarget_dev.h platform_retarget_pins.h system_cmsdk_musca.h system_core_musca.h system_musca.h uart_musca_b.h
    ../../../../../vendors/arm/driver_library/drivers/: uart_pl011_drv.h uart_stdout.h uart_pl011_drv.c uart_stdout.c
    ../../../../../vendors/arm/driver_library/gen_support/: hardware_setup.h print_log.h hardware_setup.c print_log.c
    ../../../../../vendors/arm/driver_library/Device/startup/: startup_cmsdk_musca_ns.s system_core_init.c
    ../../../../../vendors/arm/driver_library/Device/source/: platform_retarget_dev.c
  group libraries/abstractions/pkcs11/psa
    ../../../../../libraries/abstractions/pkcs11/psa/: iot_pkcs11_psa.c iot_pkcs11_psa_input_format.c iot_pkcs11_psa_input_format.h iot_pkcs11_psa_object_management.c iot_pkcs11_psa_object_management.h
  group vendors/arm/boards/musca-b1/aws_tests/application_code
    ../../../../../vendors/arm/boards/musca-b1/aws_tests/application_code/: main.c
  group vendors/arm/boards/musca-b1/aws_tests/config_files
    ../../../../../vendors/arm/boards/musca-b1/aws_tests/config_files/: aws_test_runner_config.h FreeRTOSConfig.h iot_pkcs11_config.h iot_test_pkcs11_config.h unity_config.h FreeRTOSIPConfig.h
  group vendors/arm/boards/musca-b1/aws_tests/application_code/arm_code
    ../../../../../vendors/arm/boards/musca-b1/aws_tests/application_code/arm_code/: flash_layout.h region_defs.h
  group libraries/3rdparty/unity/src/
    ../../../../../libraries/3rdparty/unity/src/: unity.h unity_internals.h unity.c
  group libraries/3rdparty/unity/extras/fixture/src
    ../../../../../libraries/3rdparty/unity/extras/fixture/src/: unity_fixture.h unity_fixture_internals.h unity_fixture_malloc_overrides.h unity_fixture.c
  group demos/dev_mode_key_provisioning/src
    ../../../../../demos/dev_mode_key_provisioning/src/: aws_dev_mode_key_provisioning.c
  group demos/dev_mode_key_provisioning/include
    ../../../../../demos/dev_mode_key_provisioning/include/: aws_dev_mode_key_provisioning.h
  group libraries/3rdparty/pkcs11
    ../../../../../libraries/3rdparty/pkcs11/: pkcs11.h pkcs11f.h pkcs11t.h
  group libraries/3rdparty/mbedtls/utils
    ../../../../../libraries/3rdparty/mbedtls/utils/: mbedtls_utils.c
  group libraries/freertos_plus/standard/crypto/src
    ../../../../../libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group libraries/freertos_plus/standard/crypto/include
    ../../../../../libraries/freertos_plus/standard/crypto/include/: iot_crypto.h
  group libraries/freertos_plus/standard/pkcs11/include
    ../../../../../libraries/freertos_plus/standard/pkcs11/include/: iot_pkcs11.h
  group libraries/freertos_plus/standard/pkcs11/src
    ../../../../../libraries/freertos_plus/standard/pkcs11/src/: iot_pkcs11.c
  group libraries/freertos_plus/standard/utils/src
    ../../../../../libraries/freertos_plus/standard/utils/src/: iot_pki_utils.c
  group libraries/3rdparty/mbedtls/library
    ../../../../../libraries/3rdparty/mbedtls/library/: aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c threading.c timing.c version.c version_features.c xtea.c x509_crt.c x509.c x509_create.c x509_crl.c x509_csr.c x509write_crt.c x509write_csr.c aes.c cipher_wrap.c
  group freertos_kernel
    ../../../../../freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos_kernel/port
    ../../../../../freertos_kernel/portable/GCC/ARM_CM33_TFM/: os_wrapper_freertos.c port.c portasm.c portasm.h portmacro.h tz_context.h tz_context_mgmt.c tz_context_mgmt.h
    ../../../../../freertos_kernel/portable/Common/: mpu_wrappers.c
    ../../../../../../trusted-firmware-m/build/install/export/tfm/src/: tfm_sst_ipc_api.c tfm_psa_ns_api.c tfm_ns_interface.c tfm_crypto_ipc_api.c tfm_crypto_func_api.c tfm_sst_func_api.c
    ../../../../../../trusted-firmware-m/build/install/export/tfm/veneers/: s_veneers.o
    ../../../../../freertos_kernel/portable/MemMang/: heap_4.c
  group libraries/c_sdk/standard/common/logging
    ../../../../../libraries/c_sdk/standard/common/logging/: iot_logging_task_dynamic_buffers.c
    ../../../../../libraries/c_sdk/standard/common/include/: iot_logging_task.h
target Library Model (6090000::V6.9::.\ARMCLANG)
  device: Musca_B1:Cortex-M33-0 ARM
  pack: ARM.Musca_B1_BSP.1.1.0
  cpu: as above
  output: tfm_demo +hex
  AfterMake: fromelf.exe --bin --output=.\Objects\MUSCA_B_DEMO.bin .\Objects\tfm_demo.axf
  AfterMake: python ../../../../../vendors/arm/boards/musca-b1/aws_tests/tfm_rtos_mcuboot_integrate.py --ns_bin=.\Objects\MUSCA_B_DEMO.bin --tfm=..\..\..\..\..\..\trusted-firmware-m --platform=MUSCA_B1
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: UNITY_INCLUDE_CONFIG_H TFM_PARTITION_PLATFORM TFM_PARTITION_CRYPTO TFM_PARTITION_SECURE_STORAGE
  c include: ..\..\..\..\..\..\trusted-firmware-m\build\install\export\tfm\include;..\..\..\..\..\freertos_kernel\include;..\..\..\..\..\vendors\arm\driver_library\gen_support;..\..\..\..\..\vendors\arm\driver_library\drivers;..\..\..\..\..\vendors\arm\driver_library\Device\include;..\..\..\..\..\vendors\arm\driver_library\Device\config;..\..\..\..\..\vendors\arm\driver_library\cmsis\config;..\..\..\..\..\vendors\arm\driver_library\cmsis\include;..\..\..\..\..\vendors\arm\boards\musca-b1\aws_tests\application_code\arm_code;..\..\..\..\..\vendors\arm\boards\musca-b1\aws_tests\config_files;..\..\..\..\..\freertos_kernel\include;..\..\..\..\..\libraries\abstractions\pkcs11\include;..\..\..\..\..\libraries\freertos_plus\standard\pkcs11\include;..\..\..\..\..\libraries\3rdparty\pkcs11;..\..\..\..\..\tests\include;..\..\..\..\..\libraries\3rdparty\unity\src;..\..\..\..\..\libraries\3rdparty\unity\extras\fixture\src;..\..\..\..\..\demos\dev_mode_key_provisioning\include;..\..\..\..\..\libraries\freertos_plus\standard\crypto\include;..\..\..\..\..\libraries\3rdparty\mbedtls\include;..\..\..\..\..\libraries\c_sdk\standard\common\include;..\..\..\..\..\libraries\freertos_plus\standard\utils\include;..\..\..\..\..\libraries\c_sdk\standard\common\include\private;..\..\..\..\..\libraries\abstractions\pkcs11\mbedtls;..\..\..\..\..\vendors\arm\driver_library\cmsis\drivers;..\..\..\..\..\vendors\arm\boards\musca-b1\aws_tests\application_code\arm_code;..\..\..\..\..\libraries\freertos_plus\standard\utils\include;..\..\..\..\..\freertos_kernel\portable\GCC\ARM_CM33_TFM;..\..\..\..\..\libraries\abstractions\secure_sockets\include;..\..\..\..\..\vendors\arm\third_party\ESP_AT_Lib-0.5.0\src\include;..\..\..\..\..\libraries\freertos_plus\standard\tls\include;..\..\..\..\..\libraries\abstractions\wifi\include;..\..\..\..\..\..\trusted-firmware-m\build\install\export\tfm\include\psa
  memory RVCT1: ROM 0x10000000 size 0x800000
  memory RVCT2: ROM 0x0 size 0x800000
  memory RVCT3: ROM 0x1a200000 size 0x200000
  memory RVCT4: ROM 0x1a000000 size 0x200000
  memory RVCT5: ROM 0xa000000 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x80000
  memory RVCT10: RAM 0x20000000 size 0x80000
  scatter file: as above
